v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 -500 340 -500 720 {}
L 4 -500 340 580 340 {}
L 4 580 340 580 720 {}
L 4 -500 720 580 720 {}
L 4 1040 340 1040 720 {}
L 4 1040 340 2120 340 {}
L 4 2120 340 2120 720 {}
L 4 1040 720 2120 720 {}
L 4 2580 340 2580 720 {}
L 4 2580 340 3660 340 {}
L 4 3660 340 3660 720 {}
L 4 2580 720 3660 720 {}
L 4 4120 340 4120 720 {}
L 4 4120 340 5200 340 {}
L 4 5200 340 5200 720 {}
L 4 4120 720 5200 720 {}
N 5260 420 5260 440 { lab=#net1}
N -840 180 -580 180 { lab=Vdd}
N -820 180 -820 220 { lab=Vdd}
N -820 220 -780 220 { lab=Vdd}
N -640 240 2340 240 { lab=#net2}
N -580 180 2340 180 { lab=Vdd}
N -80 440 -60 440 { lab=#net3}
N -80 440 -80 460 { lab=#net3}
N -80 460 100 500 { lab=#net3}
N 100 500 100 540 { lab=#net3}
N 80 540 100 540 { lab=#net3}
N -80 520 -60 520 { lab=#net4}
N -80 500 -80 520 { lab=#net4}
N -80 500 100 460 { lab=#net4}
N 100 420 100 460 { lab=#net4}
N 80 420 100 420 { lab=#net4}
N 100 420 120 420 { lab=#net4}
N -100 420 -80 420 { lab=#net5}
N -80 400 -80 420 { lab=#net5}
N -80 400 -60 400 { lab=#net5}
N -100 540 -80 540 { lab=#net6}
N -80 540 -80 560 { lab=#net6}
N -80 560 -60 560 { lab=#net6}
N 340 440 360 440 { lab=D1}
N 340 440 340 460 { lab=D1}
N 340 460 520 500 { lab=D1}
N 520 500 520 540 { lab=D1}
N 500 540 520 540 { lab=D1}
N 340 520 360 520 { lab=#net7}
N 340 500 340 520 { lab=#net7}
N 340 500 520 460 { lab=#net7}
N 520 420 520 460 { lab=#net7}
N 500 420 520 420 { lab=#net7}
N 520 420 540 420 { lab=#net7}
N 320 420 340 420 { lab=#net8}
N 340 400 340 420 { lab=#net8}
N 340 400 360 400 { lab=#net8}
N 320 540 340 540 { lab=#net9}
N 340 540 340 560 { lab=#net9}
N 340 560 360 560 { lab=#net9}
N 160 520 180 520 { lab=#net10}
N 160 440 160 520 { lab=#net10}
N 160 440 180 440 { lab=#net10}
N 80 640 120 640 { lab=#net10}
N 120 480 120 640 { lab=#net10}
N 120 480 160 480 { lab=#net10}
N 100 540 140 540 { lab=#net3}
N 140 540 140 560 { lab=#net3}
N 140 560 180 560 { lab=#net3}
N 120 420 140 420 { lab=#net4}
N 140 400 140 420 { lab=#net4}
N 140 400 180 400 { lab=#net4}
N -260 520 -240 520 { lab=#net11}
N -260 440 -260 520 { lab=#net11}
N -260 440 -240 440 { lab=#net11}
N -460 640 -60 640 { lab=#net11}
N -280 480 -260 480 { lab=#net11}
N -280 480 -280 640 { lab=#net11}
N -300 540 -260 540 { lab=#net12}
N -260 540 -260 560 { lab=#net12}
N -260 560 -240 560 { lab=#net12}
N -300 420 -260 420 { lab=#net13}
N -260 400 -260 420 { lab=#net13}
N -260 400 -240 400 { lab=#net13}
N 540 420 600 420 { lab=#net7}
N -440 560 -440 700 { lab=#net7}
N -440 700 540 700 { lab=#net7}
N -440 360 -440 400 { lab=D1}
N -440 360 560 360 { lab=D1}
N 560 360 560 540 { lab=D1}
N 520 540 600 540 { lab=D1}
N 540 420 540 700 { lab=#net7}
N -480 440 -440 440 { lab=Vdd}
N -480 420 -480 440 { lab=Vdd}
N -520 420 -480 420 { lab=Vdd}
N -480 520 -440 520 { lab=#net2}
N -480 520 -480 540 { lab=#net2}
N -520 540 -480 540 { lab=#net2}
N -520 640 -460 640 { lab=#net11}
N 600 420 640 420 { lab=#net7}
N 600 540 640 540 { lab=D1}
N 1460 440 1480 440 { lab=#net14}
N 1460 440 1460 460 { lab=#net14}
N 1460 460 1640 500 { lab=#net14}
N 1640 500 1640 540 { lab=#net14}
N 1620 540 1640 540 { lab=#net14}
N 1460 520 1480 520 { lab=#net15}
N 1460 500 1460 520 { lab=#net15}
N 1460 500 1640 460 { lab=#net15}
N 1640 420 1640 460 { lab=#net15}
N 1620 420 1640 420 { lab=#net15}
N 1640 420 1660 420 { lab=#net15}
N 1440 420 1460 420 { lab=#net16}
N 1460 400 1460 420 { lab=#net16}
N 1460 400 1480 400 { lab=#net16}
N 1440 540 1460 540 { lab=#net17}
N 1460 540 1460 560 { lab=#net17}
N 1460 560 1480 560 { lab=#net17}
N 1880 440 1900 440 { lab=D2}
N 1880 440 1880 460 { lab=D2}
N 1880 460 2060 500 { lab=D2}
N 2060 500 2060 540 { lab=D2}
N 2040 540 2060 540 { lab=D2}
N 1880 520 1900 520 { lab=#net18}
N 1880 500 1880 520 { lab=#net18}
N 1880 500 2060 460 { lab=#net18}
N 2060 420 2060 460 { lab=#net18}
N 2040 420 2060 420 { lab=#net18}
N 2060 420 2080 420 { lab=#net18}
N 1860 420 1880 420 { lab=#net19}
N 1880 400 1880 420 { lab=#net19}
N 1880 400 1900 400 { lab=#net19}
N 1860 540 1880 540 { lab=#net20}
N 1880 540 1880 560 { lab=#net20}
N 1880 560 1900 560 { lab=#net20}
N 1700 520 1720 520 { lab=#net21}
N 1700 440 1700 520 { lab=#net21}
N 1700 440 1720 440 { lab=#net21}
N 1620 640 1660 640 { lab=#net21}
N 1660 480 1660 640 { lab=#net21}
N 1660 480 1700 480 { lab=#net21}
N 1640 540 1680 540 { lab=#net14}
N 1680 540 1680 560 { lab=#net14}
N 1680 560 1720 560 { lab=#net14}
N 1660 420 1680 420 { lab=#net15}
N 1680 400 1680 420 { lab=#net15}
N 1680 400 1720 400 { lab=#net15}
N 1280 520 1300 520 { lab=#net22}
N 1280 440 1280 520 { lab=#net22}
N 1280 440 1300 440 { lab=#net22}
N 1080 640 1480 640 { lab=#net22}
N 1260 480 1280 480 { lab=#net22}
N 1260 480 1260 640 { lab=#net22}
N 1240 540 1280 540 { lab=#net23}
N 1280 540 1280 560 { lab=#net23}
N 1280 560 1300 560 { lab=#net23}
N 1240 420 1280 420 { lab=#net24}
N 1280 400 1280 420 { lab=#net24}
N 1280 400 1300 400 { lab=#net24}
N 2080 420 2140 420 { lab=#net18}
N 1100 560 1100 700 { lab=#net18}
N 1100 700 2080 700 { lab=#net18}
N 1100 360 1100 400 { lab=D2}
N 1100 360 2100 360 { lab=D2}
N 2100 360 2100 540 { lab=D2}
N 2060 540 2140 540 { lab=D2}
N 2080 420 2080 700 { lab=#net18}
N 1060 440 1100 440 { lab=Vdd}
N 1060 420 1060 440 { lab=Vdd}
N 1020 420 1060 420 { lab=Vdd}
N 1060 520 1100 520 { lab=#net2}
N 1060 520 1060 540 { lab=#net2}
N 1020 540 1060 540 { lab=#net2}
N 1020 640 1080 640 { lab=#net22}
N 2140 420 2180 420 { lab=#net18}
N 2140 540 2180 540 { lab=D2}
N 640 420 740 420 { lab=#net7}
N 3000 440 3020 440 { lab=#net25}
N 3000 440 3000 460 { lab=#net25}
N 3000 460 3180 500 { lab=#net25}
N 3180 500 3180 540 { lab=#net25}
N 3160 540 3180 540 { lab=#net25}
N 3000 520 3020 520 { lab=#net26}
N 3000 500 3000 520 { lab=#net26}
N 3000 500 3180 460 { lab=#net26}
N 3180 420 3180 460 { lab=#net26}
N 3160 420 3180 420 { lab=#net26}
N 3180 420 3200 420 { lab=#net26}
N 2980 420 3000 420 { lab=#net27}
N 3000 400 3000 420 { lab=#net27}
N 3000 400 3020 400 { lab=#net27}
N 2980 540 3000 540 { lab=#net28}
N 3000 540 3000 560 { lab=#net28}
N 3000 560 3020 560 { lab=#net28}
N 3420 440 3440 440 { lab=D3}
N 3420 440 3420 460 { lab=D3}
N 3420 460 3600 500 { lab=D3}
N 3600 500 3600 540 { lab=D3}
N 3580 540 3600 540 { lab=D3}
N 3420 520 3440 520 { lab=#net29}
N 3420 500 3420 520 { lab=#net29}
N 3420 500 3600 460 { lab=#net29}
N 3600 420 3600 460 { lab=#net29}
N 3580 420 3600 420 { lab=#net29}
N 3600 420 3620 420 { lab=#net29}
N 3400 420 3420 420 { lab=#net30}
N 3420 400 3420 420 { lab=#net30}
N 3420 400 3440 400 { lab=#net30}
N 3400 540 3420 540 { lab=#net31}
N 3420 540 3420 560 { lab=#net31}
N 3420 560 3440 560 { lab=#net31}
N 3240 520 3260 520 { lab=#net32}
N 3240 440 3240 520 { lab=#net32}
N 3240 440 3260 440 { lab=#net32}
N 3160 640 3200 640 { lab=#net32}
N 3200 480 3200 640 { lab=#net32}
N 3200 480 3240 480 { lab=#net32}
N 3180 540 3220 540 { lab=#net25}
N 3220 540 3220 560 { lab=#net25}
N 3220 560 3260 560 { lab=#net25}
N 3200 420 3220 420 { lab=#net26}
N 3220 400 3220 420 { lab=#net26}
N 3220 400 3260 400 { lab=#net26}
N 2820 520 2840 520 { lab=#net33}
N 2820 440 2820 520 { lab=#net33}
N 2820 440 2840 440 { lab=#net33}
N 2620 640 3020 640 { lab=#net33}
N 2800 480 2820 480 { lab=#net33}
N 2800 480 2800 640 { lab=#net33}
N 2780 540 2820 540 { lab=#net34}
N 2820 540 2820 560 { lab=#net34}
N 2820 560 2840 560 { lab=#net34}
N 2780 420 2820 420 { lab=#net35}
N 2820 400 2820 420 { lab=#net35}
N 2820 400 2840 400 { lab=#net35}
N 3620 420 3680 420 { lab=#net29}
N 2640 560 2640 700 { lab=#net29}
N 2640 700 3620 700 { lab=#net29}
N 2640 360 2640 400 { lab=D3}
N 2640 360 3640 360 { lab=D3}
N 3640 360 3640 540 { lab=D3}
N 3600 540 3680 540 { lab=D3}
N 3620 420 3620 700 { lab=#net29}
N 2600 440 2640 440 { lab=Vdd}
N 2600 420 2600 440 { lab=Vdd}
N 2560 420 2600 420 { lab=Vdd}
N 2600 520 2640 520 { lab=#net2}
N 2600 520 2600 540 { lab=#net2}
N 2560 540 2600 540 { lab=#net2}
N 2560 640 2620 640 { lab=#net33}
N 3680 420 3720 420 { lab=#net29}
N 3680 540 3720 540 { lab=D3}
N 2180 420 2280 420 { lab=#net18}
N 4540 440 4560 440 { lab=#net36}
N 4540 440 4540 460 { lab=#net36}
N 4540 460 4720 500 { lab=#net36}
N 4720 500 4720 540 { lab=#net36}
N 4700 540 4720 540 { lab=#net36}
N 4540 520 4560 520 { lab=#net37}
N 4540 500 4540 520 { lab=#net37}
N 4540 500 4720 460 { lab=#net37}
N 4720 420 4720 460 { lab=#net37}
N 4700 420 4720 420 { lab=#net37}
N 4720 420 4740 420 { lab=#net37}
N 4520 420 4540 420 { lab=#net38}
N 4540 400 4540 420 { lab=#net38}
N 4540 400 4560 400 { lab=#net38}
N 4520 540 4540 540 { lab=#net39}
N 4540 540 4540 560 { lab=#net39}
N 4540 560 4560 560 { lab=#net39}
N 4960 440 4980 440 { lab=D4}
N 4960 440 4960 460 { lab=D4}
N 4960 460 5140 500 { lab=D4}
N 5140 500 5140 540 { lab=D4}
N 5120 540 5140 540 { lab=D4}
N 4960 520 4980 520 { lab=#net1}
N 4960 500 4960 520 { lab=#net1}
N 4960 500 5140 460 { lab=#net1}
N 5140 420 5140 460 { lab=#net1}
N 5120 420 5140 420 { lab=#net1}
N 5140 420 5160 420 { lab=#net1}
N 4940 420 4960 420 { lab=#net40}
N 4960 400 4960 420 { lab=#net40}
N 4960 400 4980 400 { lab=#net40}
N 4940 540 4960 540 { lab=#net41}
N 4960 540 4960 560 { lab=#net41}
N 4960 560 4980 560 { lab=#net41}
N 4780 520 4800 520 { lab=#net42}
N 4780 440 4780 520 { lab=#net42}
N 4780 440 4800 440 { lab=#net42}
N 4700 640 4740 640 { lab=#net42}
N 4740 480 4740 640 { lab=#net42}
N 4740 480 4780 480 { lab=#net42}
N 4720 540 4760 540 { lab=#net36}
N 4760 540 4760 560 { lab=#net36}
N 4760 560 4800 560 { lab=#net36}
N 4740 420 4760 420 { lab=#net37}
N 4760 400 4760 420 { lab=#net37}
N 4760 400 4800 400 { lab=#net37}
N 4360 520 4380 520 { lab=#net43}
N 4360 440 4360 520 { lab=#net43}
N 4360 440 4380 440 { lab=#net43}
N 4160 640 4560 640 { lab=#net43}
N 4340 480 4360 480 { lab=#net43}
N 4340 480 4340 640 { lab=#net43}
N 4320 540 4360 540 { lab=#net44}
N 4360 540 4360 560 { lab=#net44}
N 4360 560 4380 560 { lab=#net44}
N 4320 420 4360 420 { lab=#net45}
N 4360 400 4360 420 { lab=#net45}
N 4360 400 4380 400 { lab=#net45}
N 5160 420 5220 420 { lab=#net1}
N 4180 560 4180 700 { lab=#net1}
N 4180 700 5160 700 { lab=#net1}
N 4180 360 4180 400 { lab=D4}
N 4180 360 5180 360 { lab=D4}
N 5180 360 5180 540 { lab=D4}
N 5140 540 5220 540 { lab=D4}
N 5160 420 5160 700 { lab=#net1}
N 4140 440 4180 440 { lab=Vdd}
N 4140 420 4140 440 { lab=Vdd}
N 4100 420 4140 420 { lab=Vdd}
N 4140 520 4180 520 { lab=#net2}
N 4140 520 4140 540 { lab=#net2}
N 4100 540 4140 540 { lab=#net2}
N 4100 640 4160 640 { lab=#net43}
N 5220 420 5260 420 { lab=#net1}
N 5220 540 5260 540 { lab=D4}
N 3720 420 3820 420 { lab=#net29}
N -840 800 5440 800 { lab=RST}
N -680 660 -660 660 { lab=RST}
N -680 660 -680 800 { lab=RST}
N 860 660 880 660 { lab=RST}
N 860 660 860 800 { lab=RST}
N 2400 660 2420 660 { lab=RST}
N 2400 660 2400 800 { lab=RST}
N 3940 660 3960 660 { lab=RST}
N 3940 660 3940 800 { lab=RST}
N -980 800 -840 800 { lab=RST}
N -960 260 -780 260 { lab=RST}
N -960 260 -960 800 { lab=RST}
N 2340 240 5330 240 { lab=#net2}
N 2340 180 5320 180 { lab=Vdd}
N -540 420 -520 420 { lab=Vdd}
N -540 180 -540 420 { lab=Vdd}
N -560 540 -520 540 { lab=#net2}
N -560 240 -560 540 { lab=#net2}
N 1000 420 1020 420 { lab=Vdd}
N 1000 180 1000 420 { lab=Vdd}
N 980 540 1020 540 { lab=#net2}
N 980 240 980 540 { lab=#net2}
N 2540 420 2560 420 { lab=Vdd}
N 2540 180 2540 420 { lab=Vdd}
N 2520 540 2560 540 { lab=#net2}
N 2520 240 2520 540 { lab=#net2}
N 4080 420 4100 420 { lab=Vdd}
N 4080 180 4080 420 { lab=Vdd}
N 4060 540 4100 540 { lab=#net2}
N 4060 240 4060 540 { lab=#net2}
N -920 790 -920 800 { lab=RST}
N 740 420 740 480 { lab=#net7}
N 780 460 780 480 { lab=#net46}
N 710 460 780 460 { lab=#net46}
N 2280 420 2280 480 { lab=#net18}
N 2320 460 2320 480 { lab=#net46}
N 2240 460 2320 460 { lab=#net46}
N 3820 420 3820 480 { lab=#net29}
N 3860 460 3860 480 { lab=#net46}
N 3780 460 3860 460 { lab=#net46}
N -1000 600 -920 600 { lab=CLK}
N -960 800 -960 870 { lab=RST}
N -960 870 -940 870 { lab=RST}
N -800 880 5440 880 { lab=#net46}
N 710 460 710 880 { lab=#net46}
N 2240 460 2240 880 { lab=#net46}
N 3780 460 3780 880 { lab=#net46}
N -800 870 -800 880 { lab=#net46}
N -780 740 -780 880 { lab=#net46}
N -920 740 -780 740 { lab=#net46}
N -920 640 -920 740 { lab=#net46}
C {vdd.sym} -780 180 0 0 {name=l3 lab=Vdd}
C {ipin.sym} -980 800 0 0 {name=p6 lab=RST}
C {opin.sym} 640 540 0 0 {name=p2 lab=D1}
C {capa.sym} 5260 470 0 0 {name=C1
m=1
value=0.75p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} 5260 500 0 0 {name=l1 lab=GND}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/or_2.sym} -600 640 0 0 {name=x13}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 0 420 0 0 {name=x1}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 0 540 0 0 {name=x2}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} -180 420 0 0 {name=x5}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} -180 540 0 0 {name=x7}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} 0 640 0 0 {name=x8}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 420 420 0 0 {name=x14}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 420 540 0 0 {name=x16}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 240 420 0 0 {name=x17}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 240 540 0 0 {name=x19}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} -380 420 0 0 {name=x21}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} -380 540 0 0 {name=x22}
C {/home/matteo/Documenti/tesi/Circuiti/latches_sch_sym/edg_det.sym} -720 620 0 0 {name=x24}
C {opin.sym} 2180 540 0 0 {name=p3 lab=D2}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/or_2.sym} 940 640 0 0 {name=x25}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 1540 420 0 0 {name=x26}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 1540 540 0 0 {name=x27}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1360 420 0 0 {name=x28}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1360 540 0 0 {name=x29}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} 1540 640 0 0 {name=x30}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 1960 420 0 0 {name=x31}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 1960 540 0 0 {name=x32}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1780 420 0 0 {name=x33}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1780 540 0 0 {name=x34}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1160 420 0 0 {name=x35}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 1160 540 0 0 {name=x36}
C {/home/matteo/Documenti/tesi/Circuiti/latches_sch_sym/edg_det.sym} 820 620 0 0 {name=x37}
C {opin.sym} 3720 540 0 0 {name=p4 lab=D3}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/or_2.sym} 2480 640 0 0 {name=x38}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 3080 420 0 0 {name=x39}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 3080 540 0 0 {name=x40}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 2900 420 0 0 {name=x41}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 2900 540 0 0 {name=x42}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} 3080 640 0 0 {name=x43}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 3500 420 0 0 {name=x44}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 3500 540 0 0 {name=x45}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 3320 420 0 0 {name=x46}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 3320 540 0 0 {name=x47}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 2700 420 0 0 {name=x48}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 2700 540 0 0 {name=x49}
C {/home/matteo/Documenti/tesi/Circuiti/latches_sch_sym/edg_det.sym} 2360 620 0 0 {name=x50}
C {opin.sym} 5260 540 0 0 {name=p5 lab=D4}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/or_2.sym} 4020 640 0 0 {name=x51}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 4620 420 0 0 {name=x52}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 4620 540 0 0 {name=x53}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4440 420 0 0 {name=x54}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4440 540 0 0 {name=x55}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} 4620 640 0 0 {name=x56}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 5040 420 0 0 {name=x57}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} 5040 540 0 0 {name=x58}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4860 420 0 0 {name=x59}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4860 540 0 0 {name=x60}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4240 420 0 0 {name=x61}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 4240 540 0 0 {name=x62}
C {/home/matteo/Documenti/tesi/Circuiti/latches_sch_sym/edg_det.sym} 3900 620 0 0 {name=x63}
C {ipin.sym} -1000 600 0 0 {name=p1 lab=CLK}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} -880 870 0 0 {name=x10}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} -860 620 0 0 {name=x4}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 760 540 1 0 {name=x3}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 2300 540 1 0 {name=x6}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/and_2.sym} 3840 540 1 0 {name=x9}
