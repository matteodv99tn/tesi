v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/nor_2.sym} -40 0 0 0 {name=x1}
C {/home/matteo/Documenti/tesi/Circuiti/logic_gates_sch_sym/not.sym} 100 0 0 0 {name=x2}
C {ipin.sym} -100 -20 0 0 {name=p1 lab=A}
C {ipin.sym} -100 20 0 0 {name=p2 lab=B}
C {opin.sym} 180 0 0 0 {name=p3 lab=Y}
